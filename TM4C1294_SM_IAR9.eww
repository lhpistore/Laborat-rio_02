<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\Exerc_10\src\Exerc_10.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_11\src\Exerc_11.ewp</path>
    </project>
    <batchBuild />
</workspace>
